## boards/shields/treenail/Kconfig.defconfig
```kconfig
if SHIELD_TREENAIL

config ZMK_KEYBOARD_NAME
    default "treenail"

endif # SHIELD_TREENAIL
```
